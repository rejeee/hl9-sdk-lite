# IAR project MHL9.ewp, settings and files
configuration M-HL9-Lite-TX (ARM, debug)
  General.OGChipSelectEditMenu: HC32L130F8UA HDSC HC32L130F8UA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __CORTEX_M0; __CMSIS_RTOS
  ICCARM.CCIncludePath2: ..\..\..\kernel\CMSIS\Include; ..\..\..\kernel\CMSIS\RTOS\RTX\INC; ..\..\..\bsp; ..\..\..\bsp\cpu; ..\..\..\bsp\cpu\HDSC; ..\..\..\bsp\cpu\HDSC\HC32L13X; ..\..\..\bsp\cpu\HDSC\HC32L13X\driver\inc; ..\..\..\bsp\platform; ..\..\..\bsp\platform\common; ..\..\..\libs; ..\..\..\app; ..\..\..\net; ..\config; ..\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: M-HL9V3.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: hc32l130f8ua.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\libs\rjhl9-lite.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration M-HL9-Lite-RX (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: __CORTEX_M0; __CMSIS_RTOS; USE_MODE_RX
  ICCARM.CCIncludePath2: ..\..\..\kernel\CMSIS\Include; ..\..\..\kernel\CMSIS\RTOS\RTX\INC; ..\..\..\bsp; ..\..\..\bsp\cpu; ..\..\..\bsp\cpu\HDSC; ..\..\..\bsp\cpu\HDSC\HC32L13X; ..\..\..\bsp\cpu\HDSC\HC32L13X\driver\inc; ..\..\..\bsp\platform\common; ..\..\..\libs; ..\..\..\app; ..\..\..\net; ..\config; ..\
  group APP
    ../../../app/: app.c main.c
  group BSP
    ../../../bsp/: bsp.h
  group BSP/cpu/HDSC/HC32L13X/driver/src
    ../../../bsp/cpu/HDSC/HC32L13X/driver/src/: aes.c ddl.c flash.c gpio.c interrupts_hc32l13x.c lpm.c lpt.c lpuart.c reset.c spi.c sysctrl.c uart.c wdt.c
  group BSP/platform
    ../../../bsp/platform/: platform.h
  group CFG
    ../config/: app_cfg.h RTX_Conf_CM.c
  group HAL
    ../hal/: hal_led.c
  group Kernel/RTX
    ../../../kernel/CMSIS/RTOS/RTX/SRC/: HAL_CM.c rt_CMSIS.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Memory.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
  group Kernel/RTX/IAR
    ../../../kernel/CMSIS/RTOS/RTX/SRC/IAR/: HAL_CM0.s SVC_Table.s
  group Startup
    ../../../bsp/cpu/HDSC/HC32L13X/: system_hc32l13x.c
  group Startup/IAR
    ../../../bsp/cpu/HDSC/HC32L13X/startup/iar/: startup_hc32l13x.s
  group User
    ../: app_at.c app_project.c platform_mhl9.c
